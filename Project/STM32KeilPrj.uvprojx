# Keil uVision project STM32KeilPrj.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32KeilPrj +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=167,177
  c include: ..\App\Main;..\App\DataType;..\HW\RCC;..\HW\Timer;..\HW\UART1;..\FW\inc;..\ARM\NVIC;..\ARM\SysTick;..\ARM\System;..\App\LED;..\App\OLED;..\App\RunClock;..\App\KeyOne;..\App\Game
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group App
    ../App/Main/: Main.c
    ../App/LED/: LED.c LED.h
    ../App/RunClock/: RunClock.c RunClock.h
    ../App/DataType/: DataType.h
    ../App/KeyOne/: KeyOne.c KeyOne.h ProcKeyOne.c ProcKeyOne.h
    ../App/OLED/: OLED.c OLED.h OLEDFont.h
    ../App/Game/: Game.c Game.h KeyNew.c KeyNew.h LEDNew.c LEDNew.h Random.c Random.h
  group HW
    ../HW/RCC/: RCC.c
    ../HW/Timer/: Timer.c
    ../HW/UART1/: Queue.c UART1.c
  group FW
    ../FW/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group ARM
    ../ARM/System/: stm32f10x_it.c core_cm3.c startup_stm32f10x_hd.s
    ../ARM/NVIC/: NVIC.c
    ../ARM/SysTick/: SysTick.c
    ./RTE/Device/STM32F103RC/: system_stm32f10x.c
